options:
  parameters:
    generate_options: no_gui
    id: simple_correlator
    output_language: python
    run_options: run
  states: {}

blocks:
- name: corr_probeval
  id: variable_function_probe
  parameters:
    block_id: corr_probe
    function_name: level
    poll_rate: 1.0/2.0
    value: '0.0'
  states: {}
- name: corr_rate
  id: variable
  parameters:
    comment: |-
      Control first-layer output
      rate of correlator, in Hz
    value: '100'
  states: {}
- name: fperiod
  id: variable
  parameters:
    comment: Fringe period (secs)
    value: corr_logger.fperiod(freq,baseline,decln,latitude)
  states: {}
- name: logsts
  id: variable
  parameters:
    value: corr_logger.logval(corr_probeval, outfile)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(srate)
  states: {}
- name: baseline
  id: parameter
  parameters:
    label: Baseline length, meters
    type: eng_float
    value: '10'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Reduce sample rate
      fringes are slow for
      smaller baselines
    n: corr_rate
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/corr_rate)
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Simple correlate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      EAST ant input
      possibly phase adjust
    const: complex(math.cos(math.radians(eastcorr)), math.sin(math.radians(eastcorr)))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      WEST ant input
      possibly phase adjust
    const: complex(math.cos(math.radians(westcorr)), math.sin(math.radians(westcorr)))
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: corr_logger
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import time
      import math

      #
      # Log a complex input value, with a computed filename, and a (UTC) timestamp
      # Use a simple CSV format
      #
      def logval(val,fn):
          ltp = time.gmtime()
          filestr="%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
          filestr = fn+"-"+filestr+".csv"
          fp = open(filestr, "a")
          fp.write("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
          fp.write("%-11.9f,%-11.9f\n" % (val.real, val.imag))
          fp.close()
          return None
          
      def fperiod(freq,baseline,decln,latitude):
          C=299792000.0
          Lambda = C/freq
          #
          # Convert baseline into fringe-spacing in degrees
          #
          fwidth= (math.degrees(Lambda))/baseline
          
          #
          # 240 seconds (4 minutes) per degree on the celestial equator
          #
          fwidth *= (4.0 * 60.0)
          
          #
          # Adjust for declination and local latitude
          # Takes longer for source to transit through 'fwidth' at higher
          # declinations
          #
          fwidth /= math.cos(math.radians(decln))
          return fwidth

      def getalpha(corner, srate):
          q = math.pow(math.e,-2.0*(corner/srate))
          alpha = 1.0 - q
          return alpha
  states: {}
- name: corr_probe
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: decln
  id: parameter
  parameters:
    label: Declination, degrees
    type: eng_float
    value: '0.0'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    value: '"uhd,type=b200,nchan=2"'
  states: {}
- name: eastcorr
  id: parameter
  parameters:
    label: East static phase correction (deg)
    type: eng_float
    value: '0.0'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import sys
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: Local geo latitude
    type: eng_float
    value: '0.0'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Here we poll the output of
      the PROBE block at a 2-second
      cadence, and log the results
      via the 'corr_logger' python module
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      This implements a simple high-pass
      or DC blocker.  It will handily eliminate
      DC offsets caused by constant-phase
      RFI artifacts, so that you mostly
      get either noise or nice fringes
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    bb_gain1: '20'
    bw0: samp_rate
    bw1: samp_rate
    corr1: '0'
    dc_offset_mode0: '2'
    dc_offset_mode1: '2'
    freq0: freq
    freq1: freq
    gain0: rfgain
    gain1: rfgain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode0: '2'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output Filename prefix
    value: '"output.dat"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '50'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: corr_logger.getalpha(1.0/2.0,corr_rate)
    comment: |-
      Simple integrator via
      IIR filter
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: corr_logger.getalpha(1.0/fperiod,corr_rate)
    comment: |-
      Longer-period integrator
      Forms the lower half of
      a high-pass filter
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate/(corr_rate*1.5))
    comment: |-
      First layer of filtering
      Reduce output rate to
      corr_rate
    type: complex
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 4.0e6
  states: {}
- name: westcorr
  id: parameter
  parameters:
    label: West static phase correction (deg)
    type: eng_float
    value: '0.0'
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', corr_probe, '0']
- [blocks_keep_one_in_n_1, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', single_pole_iir_filter_xx_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_sub_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '1', blocks_multiply_const_vxx_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_2, '0', blocks_keep_one_in_n_1, '0']

metadata:
  file_format: 1
